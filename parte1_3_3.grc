options:
  parameters:
    generate_options: qt_gui
    id: modulador_de_amplitud
    output_language: python
    title: modulador de amplitud
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud portadora (Ac)
    start: '0'
    step: '1e-3'
    stop: '1'
    value: '125e-3'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: 'Amplitud Mensaje '
    start: '0'
    step: '100e-3'
    stop: '4'
    value: '1'
  states: {}
- name: B
  id: variable_qtgui_range
  parameters:
    label: 'cambio de banda '
    start: '-1'
    step: '2'
    stop: '1'
    value: '1'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: 'Ganancia Trasmisor '
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: K
  id: variable_qtgui_range
  parameters:
    label: Habilita Portadora
    start: '0'
    step: '1'
    stop: '1'
    value: '1'
  states: {state: disabled}
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: frecuencia de portadora
    start: 50e6
    step: 1e6
    stop: 02.2e9
    value: 50e6
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: 'freceuncia mensaje '
    start: '300'
    step: '100'
    stop: samp_rate/4
    value: 1e3
  states: {}
- name: ka
  id: variable_qtgui_range
  parameters:
    label: Coeficiente de sensibilidad AM
    start: '-4'
    step: '0.01'
    stop: '4'
    value: '1'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    label: Frecuencia de muestreo
    start: '1000'
    step: '1000'
    stop: '300000'
    value: '200000'
  states: {}
- name: CalculoPComunicaciones_0
  id: CalculoPComunicaciones
  parameters:
    l_vect: '1024'
  states: {}
- name: EnvolventeCompleja_0
  id: EnvolventeCompleja
  parameters:
    Ac: Ac
    ka: ka
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: Am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/labcom/Descargas/rebelion_joearroyo.wav-20230914T195838Z-001/rebelion_joearroyo.wav
    repeat: 'True'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: audio_rate
    interp: samp_rate
    type: fff
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: GTX
    otw: sc16
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [EnvolventeCompleja_0, '0', qtgui_freq_sink_x_0, '0']
- [EnvolventeCompleja_0, '0', qtgui_time_sink_x_0, '0']
- [EnvolventeCompleja_0, '0', uhd_usrp_sink_0, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', CalculoPComunicaciones_0, '0']
- [rational_resampler_xxx_0, '0', EnvolventeCompleja_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
